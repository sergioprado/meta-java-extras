require openjdk7.inc 

SUMMARY = "A small image with OpenJDK 7 support" 

LICENSE = "MIT"

inherit core-image 
